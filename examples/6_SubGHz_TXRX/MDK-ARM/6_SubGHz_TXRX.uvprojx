# Keil uVision project 6_SubGHz_TXRX.uvprojx, settings and files
target 6_SubGHz_TXRX (6220000::V6.22::ARMCLANG)
  device: STM32WL55CCUx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20008000-0x2000BFFF) IROM(0x8000000-0x801FFFF)  CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: 6_SubGHz_TXRX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c include: ../Core/Inc;../SubGHz_Phy/App;../SubGHz_Phy/Target;../Utilities/trace/adv_trace;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Utilities/misc;../Utilities/timer;../Utilities/lpm/tiny_lpm;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Middlewares/Third_Party/SubGHz_Phy;../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3;../User;../SEGGER-RTT
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c rtc.c spi.c subghz.c stm32_lpm_if.c sys_app.c sys_debug.c timer_if.c usart_if.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c stm32wlxx_hal_timebase_tim.c
  group Application/User/SubGHz_Phy/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/User/SubGHz_Phy/Target
    ../SubGHz_Phy/Target/: radio_board_if.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: lr_fhss_mac.c radio.c radio_driver.c radio_fw.c wl_lr_fhss.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group User
    ../User/: user.c oled.c sdcard.c
  group SEGGER-RTT
    ../SEGGER-RTT/: lib_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
